<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\F1_Nokia5110DMA.ewp</path>
  </project>
  <batchBuild />
</workspace>
